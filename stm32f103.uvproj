# Keil uVision project stm32f103.uvproj, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\EDP;.\hardware\inc;.\user;.\NET\protocol\inc;.\NET\device\demo\SIM800C;.\nmea_decode\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
  group hardware
    ./hardware/src/: at24c02.c beep.c delay.c hwtimer.c i2c.c info.c key.c led.c selfcheck.c usart.c gps_config.c lcd1602.c gy30.c oled.c
  group user
    ./user/: main.c onenetAPP.c FONT.c dataStreamName.h
  group net_protocol
    ./NET/protocol/src/: fault.c onenet.c dStream.c http_stream.c
  group net_device
    ./NET/device/demo/SIM800C/: net_device.c net_io.c
  group nmealib
    ./nmea_decode/src/: context.c generate.c generator.c gmath.c parse.c parser.c sentence.c time.c tok.c
